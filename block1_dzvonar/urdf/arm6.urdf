Commit message: zadanie7 spraveny bonus

File: block1_dzvonar/urdf/arm6.urdf (robot description, URDF)
Before this commit: robot arm6, 11 links, 10 joints
Links:
- link link_4: geometry visual cylinder length=0.03 radius=0.01
- link link_6: geometry visual sphere radius=0.01
